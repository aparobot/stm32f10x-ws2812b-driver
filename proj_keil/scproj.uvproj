# Keil uVision project scproj.uvproj, settings and files
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: smartcar
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,IR_DEBUG
  c misc: --c99
  c include: ..\lib\CMSIS\Core\CM3;..\lib\STM32F10x_StdPeriph_Driver\inc;..\config;..\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cmsis
    ../lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_ld.s
  group stm32lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_i2c.c
  group init
    ../init/: main.c
    ../drivers/src/: ws2812b.c
